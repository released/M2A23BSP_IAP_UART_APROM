LOAD_ROM_1  0x00000000 0x3000
{
	APROM_Bootloader.bin  0x00000000 0x3000
	{
		startup_m2a23.o (RESET, +FIRST)
        .ANY (+RO)
	}
	
	SRAM  0x20000000 0x6000
	{
		* (+RW, +ZI)
	}
}