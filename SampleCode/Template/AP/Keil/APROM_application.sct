LOAD_ROM_1  0x3000 0x1D000
{
	APROM_application.bin  0x3000 0x1D000
	{
		startup_m2a23.o (RESET, +FIRST)
        .ANY (+RO)
	}
	SRAM  0x20000000 0x6000
	{
		* (+RW, +ZI)
	}
}